Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: fe595b37-2071-43d7-8f47-0c74231f2249, NumberOfSaves: 14], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Default Site]
File name: ROTHOB_Rothoblaas_Plate_WHTPlateT_300.ifc
Time: 2026-03-30T11:13:24
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 01
LongName: ROTHOBLAAS

# IfcSite, Default
RefLatitude: 46, 17, 24, 511413; RefLongitude: 11, 14, 5, 895767; RefElevation: 0 mm
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuilding, HEADQUARTER
LongName: HEADQUARTER
Pset_BuildingCommon - NumberOfStoreys: 1
Identity Data - Author: ROTHOBLAAS; Building Name: HEADQUARTER; Organization Name: ROTHO BLAAS SRL
Other - Category: Project Information; Client Name: Owner; Project Address: Via dell'Adige N. 2/1, Cortaccia (BZ) [ITA]; Project Name: ROTHOBLAAS; Project Number: 01

# IfcBuildingStorey: Level:1/4" Head, 0_Rothoblaas
In: HEADQUARTER
LongName: 0_Rothoblaas; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: 0_Rothoblaas; sets with these values: 2
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: 0_Rothoblaas; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: 1/4" Head; Type: 1/4" Head; Type Id: 27
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Grid Line 1/2"; Line Weight: 1; Symbol: Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: 1/4" Head
Other(Type) - Category: Levels; Family Name: Level

# IfcDiscreteAccessory: Structural Connections : ROTHOB_Rothoblaas_Plate_WHTPlateT_300 : WHTPT300_67x300mm
In: 0_Rothoblaas
Type - Material: ROTHOB_Rothoblaas_CarbonSteel_ZincPlated
Type - Visibility - HasHole_WHTPT300: yes; HasHole_WHTPT530: no; HasHole_WHTPT600: no; HasHole_WHTPT720: no; HasHole_WHTPT820: no
Type - General - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_WHTPlateT; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 11; OmniClassTitle: Nail Plates; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/angle-brackets-and-plates-for-buildings/wht-plate-t; Revision: n/a; UniClass2015Code: Pr_20_29_31_12; UniClass2015Title: Carbon steel nailing plates; UniClass2015Version: Products v1.33; Version: 3
Type - Constraints - Default Elevation: 1219.2 mm; ModelNumberCode: 300
Type - Materials and Finishes - ObjectMaterial: ROTHOB_Rothoblaas_CarbonSteel_ZincPlated
Type - Dimensions - Height_H: 300 mm; HoleQuantity_nvØ11: 12; Thickness_s: 2 mm; Width_B: 67 mm
Type - Identity Data - OmniClass Number: 23.13.23.11.19.11; Type Name: WHTPT300_67x300mm
Type - Other - Category: Structural Connections; AccessibilityPerformance: n/a; AssetType: n/a; BBACode: BS EN 14545; BBATitle: n/a; CECode: EN 14545; CETitle: n/a; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: Plates for tensile loads; DurationUnit: Years; ExpectedLife: 50; Family Name: ROTHOB_Rothoblaas_Plate_WHTPlateT_300; Features: Perforated plates for structural use in load-bearing timber structures; Finish: Zinc plated; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Carbon steel; MinWeight: Temporarily not available; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: WHTPT300; ModelReference: n/a; Name: Plate; NominalHeight: 300 mm; NominalLength: n/a; NominalWidth: 67 mm; ReplacementCost: n/a; Shape: Rectangular; Size: 67x300 mm; Size_Imperial: 2 5/8x11 3/4 in; SustainabilityPerformance: n/a; UKCACode: n/a; UKCATitle: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a
Type - Pset_ProductRequirements - Name: Plate
Pset_QuantityTakeOff - Reference: WHTPT300_67x300mm
Constraints - Elevation from Level: 0 mm; Host: Reference Plane; Level: 0_Rothoblaas; Schedule Level: 0_Rothoblaas
Phasing - Phase Created: New Construction
Dimensions - Volume: 0.0000377553 m3
Other - Family: ROTHOB_Rothoblaas_Plate_WHTPlateT_300; Family and Type: ROTHOB_Rothoblaas_Plate_WHTPlateT_300: WHTPT300_67x300mm; Type: WHTPT300_67x300mm; Type Id: 972536
